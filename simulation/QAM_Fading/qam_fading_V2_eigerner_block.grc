options:
  parameters:
    author: Pross Naoki, Halter Sara Cinzia
    generate_options: qt_gui
    id: qam_fading
    output_language: python
    realtime_scheduling: '1'
    title: QAM mit Fading
  states: {}

blocks:
- name: LOS_NLOS
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 0,0,1,1'
    label: LOS_NLOS
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: amp_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 1,1,1,1'
    label: Ampliude
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0.2'
  states: {}
- name: amp_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 2,1,1,1'
    label: Ampliude 2
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: amp_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 3,1,1,1'
    label: Ampliude 3
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: chn_taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@1: 0,0,1,1'
    label: Equalizer Rate
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '.1'
    value: '.01'
  states: {}
- name: eq_mod
  id: variable
  parameters:
    value: '1'
  states: {}
- name: eq_ntaps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '350e-3'
  states: {}
- name: fading_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 1,0,1,1'
    label: Fading
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '30'
    value: '2'
  states: {}
- name: fading_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 2,0,1,1'
    label: Fading 2
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fading_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@2: 3,0,1,1'
    label: Fading 3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 1,0,1,1'
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-100e-3'
    step: '1e-3'
    stop: '100e-3'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 0,0,1,1'
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@1: 1,0,1,1'
    label: Phase Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 0,1,1,1'
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 1,1,1,1'
    label: Time Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '10e-3'
    stop: '200e-3'
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '50'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sara/Documents/Fading/simulation/QAM_Fading/qam_fading_V2_output.grc
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: chn_taps
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: eq_mod
    mu: eq_gain
    num_taps: eq_ntaps
    sps: '2'
  states: {}
- name: digital_cma_equalizer_cc_0_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: eq_mod
    mu: eq_gain
    num_taps: eq_ntaps
    sps: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: 'sps '
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, amplitudes=[], delays=[]):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.amplitues = amplitudes\n        self.delays = delays\n\n        #self.fir = \n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        inp = input_items[0]\n        oup = output_items[0]\n        amplitudes = [0.2, 0.5 ,0.8]\n        delays = [3,5,2]\n        i = len(amplitudes)\n\n        outp[:] = [([1]+[0 for n in range (0,delays[i])]+[amplitudes[i]]) for i in range(0,i)]\n\n        return len(output_items[0])\n\n\nif __name__ == '__main__':\n    ampl = [0.2, 0.5 ,0.8]\n    delays = [3,5,2]\n    i = len(ampl)\n    [([1]+[0 for n in range (0,delays[i])]+[ampl[i]]) for i in range(0,i)]\n\n\n"
    amplitudes: '[0.2, 0.5 ,0.8]'
    delays: '[3,5,2]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: params
  id: qtgui_tab_widget
  parameters:
    label0: Channel
    label1: Receiver
    label2: Fading
    num_tabs: '3'
  states: {}
- name: plots
  id: qtgui_tab_widget
  parameters:
    label0: Constellations
    label1: Frequency
    label2: Time
    num_tabs: '3'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 0,0,1,1'
    label1: fading
    label2: normal
    name: '"Channel"'
    nconnections: '2'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 0,1,1,1'
    label1: fading
    label2: normal
    name: '"Synchronized"'
    nconnections: '2'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 1,0,1,1'
    label1: fading
    label2: normal
    name: '"Equalized"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 1,1,1,1'
    label1: fading
    label2: normal
    name: '"Locked"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 0,0,1,1'
    label1: Fading
    name: '"Channel"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 1,0,1,1'
    label1: Fading
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'plots@2: 0,0,1,1'
    label1: Received
    label2: Sent
    name: '"Decoded"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_char_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_2_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_freq_sink_x_2_1, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_char_to_float_0_1, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [channels_channel_model_0, '0', epy_block_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '1']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_cma_equalizer_cc_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_cma_equalizer_cc_0_0, '0', qtgui_const_sink_x_1, '1']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_2, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_2, '1']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_cma_equalizer_cc_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0_0, '1']
- [epy_block_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
