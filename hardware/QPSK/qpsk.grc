options:
  parameters:
    author: Pross Naoki, Halter Sara Cinzia
    generate_options: qt_gui
    id: qpks
    output_language: python
    realtime_scheduling: '1'
    title: QPSK Hardware Simultion
  states: {}

blocks:
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@1: 0,0,1,1'
    label: Equalizer Rate
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '.1'
    value: '.01'
  states: {}
- name: eq_mod
  id: variable
  parameters:
    value: '2'
  states: {}
- name: eq_ntaps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@1: 1,0,1,1'
    label: Phase Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: qpsk_const
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: .4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/god/Documents/Fading/hardware/QPSK/lena512color_rx.tiff
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/god/Documents/Fading/hardware/QPSK/lena512color.tiff
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xb4,)
  states: {state: disabled}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: eq_mod
    mu: eq_gain
    num_taps: eq_ntaps
    sps: int(sps / 2)
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: int(sps / 2)
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: params
  id: qtgui_tab_widget
  parameters:
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: plots
  id: qtgui_tab_widget
  parameters:
    label0: Constellations
    label1: Frequency
    label2: Time
    label3: Bits
    num_tabs: '4'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 0,0,1,1'
    name: '"Sent (with ISI)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'plots@0: 0,2,1,1'
    name: '"Synchronized and filtered"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'plots@0: 0,1,1,1'
    name: '"Received"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 1,1,1,1'
    name: '"Equalized"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'plots@0: 1,2,1,1'
    name: '"Locked"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    name: '""'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_eye_sink_x_1
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 'plots@3: 1,0,1,1'
    name: '""'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 0,0,1,1'
    name: '"Modulated (TX)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 0,2,1,1'
    name: '"Synchronized and filtered"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 0,1,1,1'
    name: '"Received"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 1,1,1,1'
    name: '"Equalized"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'plots@1: 1,2,1,1'
    name: '"Locked"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '20'
    gui_hint: 'plots@3: 0,0,1,1'
    name: '"Sent"'
    size: 1024*4
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'plots@3: 1,0,1,1'
    ncols: '256'
    nrows: '256'
    samp_rate: samp_rate
    type: byte
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 'plots@2: 0,0,1,1'
    name: '"Modulated (TX)"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 'plots@2: 1,0,1,1'
    name: '"Received (RX)"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 2.4e9
    clock_source0: external
    dev_addr: '"serial=309AF59  "'
    dev_args: '""'
    gain0: '0.35'
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: 2.4e9
    clock_source0: external
    dc_offs_enb0: '""'
    dev_addr: '"serial=309AF6A  "'
    dev_args: '""'
    gain0: '0.6'
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_freq_sink_x_1_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_2, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1_0_1_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_file_sink_0, '0']
- [digital_map_bb_0, '0', blocks_null_sink_0, '0']
- [digital_map_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_freq_sink_x_1_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1_0_0, '0']

metadata:
  file_format: 1
