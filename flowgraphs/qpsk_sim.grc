options:
  parameters:
    author: Naoki Sean Pross, Sara Cinzia Halter
    generate_options: qt_gui
    id: qpsk_sim
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: QPSK Sim
  states: {}

blocks:
- name: access_code_symbols
  id: variable
  parameters:
    value: '[(-0.7071067811865475-0.7071067811865475j), (0.7071067811865475-0.7071067811865475j), (0.7071067811865475+0.7071067811865475j), (0.7071067811865475+0.7071067811865475j), (-0.7071067811865475-0.7071067811865475j), (0.7071067811865475+0.7071067811865475j), (0.7071067811865475-0.7071067811865475j), (0.7071067811865475-0.7071067811865475j)]'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: frame
  id: fadingui_frame_obj
  parameters:
    payload_len: '16'
    preamble: '[0x1f, 0x35]'
  states: {state: disabled}
- name: frame_len
  id: variable
  parameters:
    value: len(testvec) +4
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: 2 + 4 + 16
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: testvec
  id: variable
  parameters:
    value: '[0x1f, 0x35] + [0x12, 0x48] '
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '400'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/channel_qpsk.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: data/locked_qpsk.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: data/synchronized_qpsk.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: data/equalized_qpsk.dat
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[len(testvec), 4]'
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: '[]'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: frame_len
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: frame_start
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: testvec
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '2e-3'
    noise_voltage: '100e-3'
    seed: '243'
    taps: np.exp(1j * 30 / 180 * np.pi)
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    K: '5'
    LOS: 'False'
    N: '8'
    delays: (0,0.05e-6/samp_rate,0.12e-6/samp_rate,0.2e-6/samp_rate,0.23e-6/samp_rate,0.5e-6/samp_rate,1.6e-6/samp_rate,2.3e-6/samp_rate,5e-6/samp_rate)
    fDTs: 5/samp_rate
    mags: (0.7943282347242815,0.7943282347242815,0.7943282347242815,1,1,1,0.5011872336272722,0.31622776601683794,0.19952623149688797)
    ntaps: '9'
    seed: '0'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '2e-3'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(access_code_symbols) // 2
    sps: '1'
    symbols: access_code_symbols
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 2 * np.pi / 100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fadingui_ber_0
  id: fadingui_ber
  parameters:
    address: udp://localhost:31420
    vgl: list(np.zeros(frame_len))
    vlen: frame_len
  states: {}
- name: fadingui_datasource_0
  id: fadingui_datasource
  parameters:
    fname: ./lena512color.png
    frame_obj: frame
  states: {state: disabled}
- name: fadingui_multipath_fading_0
  id: fadingui_multipath_fading
  parameters:
    amplitudes: '[0.2, 0.08, 0.5, 0.4]'
    delays: '[0.25, 3.25, 4, 6.3]'
    los: 'False'
  states: {state: disabled}
- name: fadingui_netsink_0
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31416
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_netsink_0_0
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31415
    type: float
    veclen: '1'
  states: {}
- name: fadingui_netsink_1
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31418
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_netsink_3
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31419
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_netsink_4
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31417
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_phasecorrection_0
  id: fadingui_phasecorrection
  parameters:
    frame_len: frame_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    label1: Synchronized
    label2: Lookd
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / sps
    type: float
    ymax: '10'
    ymin: '0'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: envelope
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: envelope
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: modulated
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_mux_0, '1']
- [blocks_complex_to_mag_0, '0', fadingui_netsink_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_1, '0']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_mux_1, '0', virtual_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fadingui_ber_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_throttle_0, '0', blocks_stream_mux_1, '1']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [channels_channel_model_0, '0', channels_selective_fading_model_0, '0']
- [channels_channel_model_0, '0', fadingui_multipath_fading_0, '0']
- [channels_selective_fading_model_0, '0', blocks_file_sink_0, '0']
- [channels_selective_fading_model_0, '0', fadingui_netsink_0, '0']
- [channels_selective_fading_model_0, '0', virtual_sink_1, '0']
- [digital_cma_equalizer_cc_0, '0', blocks_file_sink_3, '0']
- [digital_cma_equalizer_cc_0, '0', digital_corr_est_cc_0, '0']
- [digital_cma_equalizer_cc_0, '0', fadingui_netsink_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_corr_est_cc_0, '0', fadingui_phasecorrection_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_file_sink_2, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', fadingui_netsink_4, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1, '1']
- [fadingui_datasource_0, '0', digital_constellation_modulator_0, '0']
- [fadingui_multipath_fading_0, '0', blocks_file_sink_0, '0']
- [fadingui_multipath_fading_0, '0', fadingui_netsink_0, '0']
- [fadingui_multipath_fading_0, '0', virtual_sink_1, '0']
- [fadingui_phasecorrection_0, '0', blocks_file_sink_1, '0']
- [fadingui_phasecorrection_0, '0', fadingui_netsink_3, '0']
- [fadingui_phasecorrection_0, '0', qtgui_const_sink_x_1, '0']
- [fadingui_phasecorrection_0, '0', virtual_sink_2, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_2, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
