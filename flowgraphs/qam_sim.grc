options:
  parameters:
    author: Naoki Sean Pross, Sara Cinzia Halter
    generate_options: qt_gui
    id: qam_sim
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: QAM Sim
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: np.exp(1j * (np.pi * 13 * np.arange(20) ** 20 / 20))
  states: {}
- name: access_code_sps
  id: variable
  parameters:
    value: np.asarray(np.matmul(np.matrix(access_code).T, np.matrix(np.ones(sps)))).ravel()
  states: {state: disabled}
- name: access_code_sps
  id: variable
  parameters:
    value: '[(1+0j), (1+0j), (1+0j), (1+0j), (-0.4539904997395467+0.8910065241883679j), (-0.4539904997395467+0.8910065241883679j), (-0.4539904997395467+0.8910065241883679j), (-0.4539904997395467+0.8910065241883679j), (0.30901699445433095+0.9510565162693603j), (0.30901699445433095+0.9510565162693603j), (0.30901699445433095+0.9510565162693603j), (0.30901699445433095+0.9510565162693603j), (-0.45399010831290065+0.8910067236300974j), (-0.45399010831290065+0.8910067236300974j), (-0.45399010831290065+0.8910067236300974j), (-0.45399010831290065+0.8910067236300974j), (0.30910023286329796+0.9510294664435246j), (0.30910023286329796+0.9510294664435246j), (0.30910023286329796+0.9510294664435246j), (0.30910023286329796+0.9510294664435246j), (0.6958765427916561+0.7181614283657487j), (0.6958765427916561+0.7181614283657487j), (0.6958765427916561+0.7181614283657487j), (0.6958765427916561+0.7181614283657487j), (0.6995785030650676+0.7145557487343022j), (0.6995785030650676+0.7145557487343022j), (0.6995785030650676+0.7145557487343022j), (0.6995785030650676+0.7145557487343022j), (-0.8755764602527171+0.4830795609952073j), (-0.8755764602527171+0.4830795609952073j), (-0.8755764602527171+0.4830795609952073j), (-0.8755764602527171+0.4830795609952073j), (-0.8320971948858552-0.5546298389584634j), (-0.8320971948858552-0.5546298389584634j), (-0.8320971948858552-0.5546298389584634j), (-0.8320971948858552-0.5546298389584634j), (0.13124680853227685+0.9913497239874998j), (0.13124680853227685+0.9913497239874998j), (0.13124680853227685+0.9913497239874998j), (0.13124680853227685+0.9913497239874998j), (0.9219105024602736-0.38740292390926256j), (0.9219105024602736-0.38740292390926256j), (0.9219105024602736-0.38740292390926256j), (0.9219105024602736-0.38740292390926256j), (0.9881969645782696-0.15318863925988194j), (0.9881969645782696-0.15318863925988194j), (0.9881969645782696-0.15318863925988194j), (0.9881969645782696-0.15318863925988194j), (-0.5511352729247617-0.8344159100461522j), (-0.5511352729247617-0.8344159100461522j), (-0.5511352729247617-0.8344159100461522j), (-0.5511352729247617-0.8344159100461522j), (-0.24665339430031927+0.9691037628036181j), (-0.24665339430031927+0.9691037628036181j), (-0.24665339430031927+0.9691037628036181j), (-0.24665339430031927+0.9691037628036181j), (-0.44951814008601154-0.8932712027898431j), (-0.44951814008601154-0.8932712027898431j), (-0.44951814008601154-0.8932712027898431j), (-0.44951814008601154-0.8932712027898431j), (-0.23300791854304934-0.9724748376673998j), (-0.23300791854304934-0.9724748376673998j), (-0.23300791854304934-0.9724748376673998j), (-0.23300791854304934-0.9724748376673998j), (1+0j), (1+0j), (1+0j), (1+0j), (0.8559628469680924+0.5170373338650489j), (0.8559628469680924+0.5170373338650489j), (0.8559628469680924+0.5170373338650489j), (0.8559628469680924+0.5170373338650489j), (-0.8354473464520049-0.5495704971214372j), (-0.8354473464520049-0.5495704971214372j), (-0.8354473464520049-0.5495704971214372j), (-0.8354473464520049-0.5495704971214372j), (-0.999246638643493+0.03880921488101298j), (-0.999246638643493+0.03880921488101298j), (-0.999246638643493+0.03880921488101298j), (-0.999246638643493+0.03880921488101298j)]'
  states: {state: disabled}
- name: carrier_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: frame
  id: fadingui_frame_obj
  parameters:
    payload_len: '4096'
    preamble: '[0xbe, 0xef]'
  states: {state: disabled}
- name: frame_len
  id: variable
  parameters:
    value: len(testvec) +4
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: testvec
  id: variable
  parameters:
    value: '[0x1f, 0x35] + [0x12, 0x48] '
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '400'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/channel_qam_sim.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: data/synchronized_qam_sim.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: data/equalized_qam_sim.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: data/locked_qam_sim.dat
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[len(testvec), 4, 0]'
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: '[len(access_code)*4, len(testvec)//4*sps]'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: frame_len
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: frame_start
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: testvec
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: access_code_sps
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '1e-3'
    noise_voltage: '100e-3'
    seed: '243'
    taps: np.exp(1j * 30 / 180 * np.pi)
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    K: '5'
    LOS: 'False'
    N: '8'
    delays: (0,0.05e-6/samp_rate,0.12e-6/samp_rate,0.2e-6/samp_rate,0.23e-6/samp_rate,0.5e-6/samp_rate,1.6e-6/samp_rate,2.3e-6/samp_rate,5e-6/samp_rate)
    fDTs: 70/samp_rate
    mags: (0.7943282347242815,0.7943282347242815,0.7943282347242815,1,1,1,0.5011872336272722,0.31622776601683794,0.19952623149688797)
    ntaps: '9'
    seed: '21'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam_const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam_const
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(access_code) // 2
    sps: '1'
    symbols: access_code
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: qam_const
    mu: '2e-3'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 2 * np.pi / 100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fadingui_ber_0
  id: fadingui_ber
  parameters:
    address: udp://localhost:31415
    vgl: testvec + list(np.zeros(4))
    vlen: frame_len
  states: {}
- name: fadingui_datasource_0
  id: fadingui_datasource
  parameters:
    fname: ''
    frame_obj: ''
  states: {state: disabled}
- name: fadingui_multipath_fading_0
  id: fadingui_multipath_fading
  parameters:
    amplitudes: '[0.12]'
    delays: '[1.8]'
    los: 'True'
  states: {}
- name: fadingui_netsink_0
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31416
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_netsink_1
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31418
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_netsink_3
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31419
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_netsink_4
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31417
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_phasecorrection_0
  id: fadingui_phasecorrection
  parameters:
    frame_len: frame_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / sps
    type: float
    ymax: '10'
    ymin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '10'
    ntaps: int(samp_rate)
    samp_rate: samp_rate
    sym_rate: 1 / sps
    type: fir_filter_ccf
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulated
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: envelope
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: envelope
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: modulated
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_mux_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '2']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_mux_1, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', fadingui_ber_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_1, '0', root_raised_cosine_filter_0, '0']
- [channels_channel_model_0, '0', channels_selective_fading_model_0, '0']
- [channels_channel_model_0, '0', fadingui_multipath_fading_0, '0']
- [channels_selective_fading_model_0, '0', blocks_file_sink_0, '0']
- [channels_selective_fading_model_0, '0', fadingui_netsink_0, '0']
- [channels_selective_fading_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_constellation_modulator_0, '0', blocks_stream_mux_1, '1']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_corr_est_cc_0, '0', fadingui_phasecorrection_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', blocks_file_sink_2, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_corr_est_cc_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', fadingui_netsink_1, '0']
- [digital_lms_dd_equalizer_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_file_sink_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', fadingui_netsink_4, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [fadingui_datasource_0, '0', digital_constellation_modulator_0, '0']
- [fadingui_multipath_fading_0, '0', blocks_file_sink_0, '0']
- [fadingui_multipath_fading_0, '0', fadingui_netsink_0, '0']
- [fadingui_multipath_fading_0, '0', virtual_sink_1, '0']
- [fadingui_phasecorrection_0, '0', blocks_file_sink_3, '0']
- [fadingui_phasecorrection_0, '0', fadingui_netsink_3, '0']
- [fadingui_phasecorrection_0, '0', qtgui_const_sink_x_0, '2']
- [fadingui_phasecorrection_0, '0', virtual_sink_2, '0']
- [root_raised_cosine_filter_0, '0', blocks_stream_mux_1, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_2, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
