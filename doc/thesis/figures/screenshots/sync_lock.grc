options:
  parameters:
    author: Naoki Sean Pross
    generate_options: qt_gui
    id: sync_lock
    output_language: python
    title: Sync and Lock for documentation figure
  states: {}

blocks:
- name: access_code_symbols
  id: variable
  parameters:
    value: 2* np.array([(-0.7071067811865475-0.7071067811865475j), (0.7071067811865475-0.7071067811865475j), (0.7071067811865475+0.7071067811865475j), (0.7071067811865475+0.7071067811865475j), (-0.7071067811865475-0.7071067811865475j), (0.7071067811865475+0.7071067811865475j), (0.7071067811865475-0.7071067811865475j), (0.7071067811865475-0.7071067811865475j)])
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: len(testvec) +4
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: testvec
  id: variable
  parameters:
    value: '[0x1f, 0x35] + [0x12, 0x48] '
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: data/equalized_qpsk_hw.dat
    type: complex
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: data/locked_qpsk_hw.dat
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: len(access_code_symbols) // 2
    sps: '1'
    symbols: access_code_symbols
    threshold: '0.65'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: qpsk_const
    mu: '3e-3'
    num_taps: '15'
    sps: '1'
  states: {}
- name: fadingui_netsink_3
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31419
    type: complex
    veclen: '1'
  states: {}
- name: fadingui_phasecorrection_0
  id: fadingui_phasecorrection
  parameters:
    frame_len: frame_len
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / sps
    type: float
    ymax: '10'
    ymin: '0'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_corr_est_cc_0, '0', fadingui_phasecorrection_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', blocks_file_sink_2, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_corr_est_cc_0, '0']
- [fadingui_phasecorrection_0, '0', blocks_file_sink_3, '0']
- [fadingui_phasecorrection_0, '0', fadingui_netsink_3, '0']
- [fadingui_phasecorrection_0, '0', virtual_sink_2, '0']

metadata:
  file_format: 1
