options:
  parameters:
    author: 'Sara Halter '
    generate_options: no_gui
    id: Map_test
    output_language: python
    title: Map test
  states: {}

blocks:
- name: a0
  id: variable
  parameters:
    value: 3.162277660168379-3.162277660168379j
  states: {}
- name: a1
  id: variable
  parameters:
    value: '-3.162277660168379-3.162277660168379j'
  states: {}
- name: a2
  id: variable
  parameters:
    value: 9.486832980505138-9.486832980505138j
  states: {}
- name: a3
  id: variable
  parameters:
    value: '-9.486832980505138-9.486832980505138j'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: v0
  id: variable
  parameters:
    value: '-0.7071067811865475-0.7071067811865475j'
  states: {}
- name: v1
  id: variable
  parameters:
    value: 0.7071067811865475-0.7071067811865475j
  states: {}
- name: v2
  id: variable
  parameters:
    value: '-0.7071067811865475+0.7071067811865475j'
  states: {}
- name: v3
  id: variable
  parameters:
    value: 0.7071067811865475+0.7071067811865475j
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[(-0.9486832980505138-0.31622776601683794j), (-0.9486832980505138-0.31622776601683794j)]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {state: bypassed}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      np.set_printoptions(formatter={'int':hex})

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Printer',
                  in_sig=[np.byte],
                  out_sig=[]
              )

          def work(self, input_items, output_items):
              inp = np.array(input_items[0], dtype=np.uint8)
              print(f"Decoded {len(inp)} samples:\n{inp}")

              return len(inp)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_1_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
