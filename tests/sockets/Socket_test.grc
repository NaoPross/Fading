options:
  parameters:
    author: 'Sara Halter '
    generate_options: no_gui
    id: Test_Bit_Errorrate
    output_language: python
    run_options: run
    title: 'Bit Error Rate test '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fadingui_netsink_0
  id: fadingui_netsink
  parameters:
    address: udp://localhost:31415
    type: float
    veclen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_1, '0']
- [blocks_null_source_0, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', fadingui_netsink_0, '0']

metadata:
  file_format: 1
