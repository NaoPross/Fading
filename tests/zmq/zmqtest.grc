options:
  parameters:
    author: Naoki Pross
    generate_options: no_gui
    id: zmqtest
    output_language: python
    realtime_scheduling: '1'
    title: ZMQ test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
