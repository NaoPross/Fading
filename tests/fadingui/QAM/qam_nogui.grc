options:
  parameters:
    author: Pross Naoki, Halter Sara Cinzia
    generate_options: no_gui
    id: qam_nogui
    output_language: python
    realtime_scheduling: '1'
    title: QAM
  states: {}

blocks:
- name: chn_taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: eq_gain
  id: variable
  parameters:
    value: '10e-3'
  states: {}
- name: eq_mod
  id: variable
  parameters:
    value: '1'
  states: {}
- name: eq_ntaps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '350e-3'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: qam_const
  id: variable_constellation_rect
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    imag_sect: '1'
    precision: '4'
    real_sect: '1'
    rot_sym: '4'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: variable_4
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: chn_taps
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: eq_mod
    mu: eq_gain
    num_taps: eq_ntaps
    sps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fadingui_datasource_0
  id: fadingui_datasource
  parameters:
    file_list: '["./lena512color.tiff"]'
    header_len: '11'
    sock_addr: udp://
    vec_len: '2037'
  states: {}
- name: fadingui_dearpygui_sink_0
  id: fadingui_dearpygui_sink
  parameters:
    sock_addr: udp://localhost:31415
    ui_element_id: '0'
  states: {state: disabled}
- name: fadingui_xor_frame_sync_0
  id: fadingui_xor_frame_sync
  parameters:
    buffer_size: '2048'
    pattern: '[0xbe, 0xef]'
    pattern_len: '16'
  states: {}

connections:
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_to_stream_0, '0', digital_constellation_modulator_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', fadingui_dearpygui_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', fadingui_xor_frame_sync_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [fadingui_datasource_0, '0', blocks_vector_to_stream_0, '0']
- [fadingui_xor_frame_sync_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
