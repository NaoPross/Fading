options:
  parameters:
    author: Pross Naoki, Halter Sara Cinzia
    generate_options: qt_gui
    id: qam_nogui
    output_language: python
    realtime_scheduling: '1'
    title: QAM
  states: {}

blocks:
- name: chn_taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@1: 0,0,1,1'
    label: Equalizer Rate
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '.1'
    value: '.01'
  states: {}
- name: eq_mod
  id: variable
  parameters:
    value: '1'
  states: {}
- name: eq_ntaps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '350e-3'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 1,0,1,1'
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-100e-3'
    step: '1e-3'
    stop: '100e-3'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 0,0,1,1'
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@1: 1,0,1,1'
    label: Phase Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: qam_const
  id: variable_constellation_rect
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    imag_sect: '1'
    precision: '4'
    real_sect: '1'
    rot_sym: '4'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 0,1,1,1'
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'params@0: 1,1,1,1'
    label: Time Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '10e-3'
    stop: '200e-3'
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: chn_taps
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: eq_mod
    mu: eq_gain
    num_taps: eq_ntaps
    sps: sps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: sps
    sps: sps * 1.001
    taps: rrc_taps
    type: ccf
  states: {}
- name: fadingui_datasource_0
  id: fadingui_datasource
  parameters:
    file_list: '["./lena512color.tiff"]'
    sock_addr: udp://
    vec_len: '512'
  states: {}
- name: params
  id: qtgui_tab_widget
  parameters:
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: plots
  id: qtgui_tab_widget
  parameters:
    label0: Constellations
    label1: Frequency
    label2: Time
    num_tabs: '3'
  states: {}

connections:
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_to_stream_0, '0', digital_constellation_modulator_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_null_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [fadingui_datasource_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
