options:
  parameters:
    author: Pross Naoki, Halter Sara Cinzia
    generate_options: qt_gui
    id: qam_nogui
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: QAM
  states: {}

blocks:
- name: chn_taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: eq_gain
  id: variable
  parameters:
    value: '.002'
  states: {}
- name: eq_mod
  id: variable
  parameters:
    value: '1'
  states: {}
- name: eq_ntaps
  id: variable
  parameters:
    value: '15'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '350e-3'
  states: {}
- name: frame
  id: fadingui_frame_obj
  parameters:
    payload_len: '32768'
    preamble: '[190, 239]'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '.01'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: 2 * 3.141592653589793 / 100
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: chn_taps
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: eq_mod
    mu: eq_gain
    num_taps: eq_ntaps
    sps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fadingui_datasource_0
  id: fadingui_datasource
  parameters:
    fname: /home/god/Documents/Fading/tests/fadingui/QAM/lena512color.tiff
    frame_obj: frame
  states: {}
- name: fadingui_dearpygui_sink_0
  id: fadingui_dearpygui_sink
  parameters:
    sock_addr: udp://localhost:31415
    ui_element_id: '0'
  states: {state: disabled}
- name: fadingui_deframer_0
  id: fadingui_deframer
  parameters:
    frame_obj: frame
  states: {}
- name: fadingui_xor_frame_sync_0
  id: fadingui_xor_frame_sync
  parameters:
    buffer_size: frame.length * 5
    pattern: frame.preamble
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color3: '"red"'
    nconnections: '3'
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_1, '0', fadingui_xor_frame_sync_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_cma_equalizer_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', fadingui_dearpygui_sink_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '2']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', fadingui_xor_frame_sync_0, '0']
- [digital_map_bb_0, '0', fadingui_xor_frame_sync_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [fadingui_datasource_0, '0', blocks_throttle_1, '0']
- [fadingui_datasource_0, '0', digital_constellation_modulator_0, '0']
- [fadingui_deframer_0, '0', blocks_null_sink_0, '0']
- [fadingui_xor_frame_sync_0, '0', fadingui_deframer_0, '0']

metadata:
  file_format: 1
