options:
  parameters:
    author: 'Sara Halter '
    generate_options: qt_gui
    id: Test_Bit_Errorrate
    output_language: python
    title: 'Bit Error Rate test '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: testvec
  id: variable
  parameters:
    value: '[31, 53] + [0x12, 0xe3, 0x9b, 0xee, 0x84, 0x23, 0x41, 0xf3]'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: testvec * 1600
  states: {}
- name: fadingui_ber_0
  id: fadingui_ber
  parameters:
    vgl: testvec
  states: {}

connections:
- [blocks_vector_source_x_0, '0', fadingui_ber_0, '0']

metadata:
  file_format: 1
