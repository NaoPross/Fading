options:
  parameters:
    author: 'Sara Halter '
    generate_options: qt_gui
    id: Test_Bit_Errorrate
    output_language: python
    title: 'Bit Error Rate test '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: testvec
  id: variable
  parameters:
    value: '[31, 53] + [0x12, 0xe3, 0x9b, 0xee, 0x84, 0x23, 0x41, 0xf3]'
  states: {}
- name: vlen
  id: variable
  parameters:
    value: '10'
  states: {}
- name: wrong
  id: variable
  parameters:
    value: list(np.random.randint(0, 255, dtype=np.uint8, size=10))
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
    vlen: vlen
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: testvec + list(np.random.randint(0, 255, dtype=np.uint8, size=10))
    vlen: vlen
  states: {}
- name: fadingui_ber_0
  id: fadingui_ber
  parameters:
    vgl: testvec
    vlen: vlen
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}

connections:
- [blocks_throttle_0, '0', fadingui_ber_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
