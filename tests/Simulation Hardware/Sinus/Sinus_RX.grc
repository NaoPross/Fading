options:
  parameters:
    author: sara
    generate_options: qt_gui
    id: Sinus_RX
    output_language: python
    title: Sinus_TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 200e3
    center_freq0: 223e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '1'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
